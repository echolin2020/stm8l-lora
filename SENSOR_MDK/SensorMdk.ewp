# IAR project SensorMdk.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\CMSIS; ..\Components\ADCPOWER; ..\Components\IWDG; ..\Components\LightSensor; ..\Components\SX1278; ..\Components\USART; ..\STM8L15x_StdPeriph_Driver\src; ..\STM8L15x_StdPeriph_Driver\inc; ..\system; ..\Components\DMA; ..\Components\sprintf; ..\STM8L15x_StdPeriph_Driver; ..\..\SENSOR V1.0 send\Components\ActiveHalt
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorMdk.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\discovery_lnk.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group CMSIS
    ../CMSIS/: stm8l15x.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group Components
    ../Components/IWDG/: IWDG.c
    ../Components/sprintf/: sprintf.c
    ../Components/SX1278/: SX1278.c
    ../Components/USART/: USART.c
  group LIB
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group Readme
    ../READ ME/: read me.txt
  group System
    ../system/: delay.c rtc.c
